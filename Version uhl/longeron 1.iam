# Autodesk Inventor assembly: longeron 1
## iProperties
Created: 2009-03
Part Number: longeron 1
Document SubType Name: Assembly
Designer: Ordi1
Author: Ordi1
