# Autodesk Inventor part: axe
## iProperties
Created: 2009-03
Part Number: axe
Document SubType Name: Modeling
Designer: Ordi1
Author: Ordi1
## Feature names
1. Extrusion1
2. Chanfrein1 [Chamfer]
