# Autodesk Inventor assembly: Ensemble-voiture
## iProperties
Created: 2008-12
Part Number: Ensemble-voiture
Document SubType Name: Assembly
Designer: Ordi1
Author: Ordi1
