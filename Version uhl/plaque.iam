# Autodesk Inventor assembly: plaque
## iProperties
Created: 2009-03
Part Number: plaque
Document SubType Name: Assembly
Designer: Ordi1
Author: Ordi1
