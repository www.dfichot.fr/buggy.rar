# Autodesk Inventor assembly: ensemble-chape
## iProperties
Created: 2009-03
Part Number: ensemble-chape
Document SubType Name: Assembly
Designer: Ordi1
Author: Ordi1
