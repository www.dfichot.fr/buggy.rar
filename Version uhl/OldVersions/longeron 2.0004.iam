# Autodesk Inventor assembly: longeron 2
## iProperties
Created: 2009-03
Part Number: longeron 2
Document SubType Name: Assembly
Designer: Ordi1
Author: Ordi1
