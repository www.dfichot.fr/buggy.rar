# Autodesk Inventor assembly: Ensemble6
## iProperties
Created: 2009-03
Part Number: Ensemble6
Document SubType Name: Assembly
Designer: Ordi1
Author: Ordi1
