# Autodesk Inventor part: chape2
## iProperties
Created: 2009-03
Part Number: chape2
Document SubType Name: Modeling
Designer: Ordi1
Author: Ordi1
## Feature names
1. Extrusion1
2. Perçage1 [Hole]
