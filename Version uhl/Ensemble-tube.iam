# Autodesk Inventor assembly: Ensemble-tube
## iProperties
Created: 2009-03
Part Number: Ensemble-tube
Document SubType Name: Assembly
Designer: Ordi1
Author: Ordi1
