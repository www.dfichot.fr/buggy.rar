# Autodesk Inventor assembly: Ensemble
## iProperties
Created: 2009-03
Part Number: Ensemble
Document SubType Name: Assembly
Designer: Ordi1
Author: Ordi1
