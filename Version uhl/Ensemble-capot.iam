# Autodesk Inventor assembly: Ensemble-capot
## iProperties
Created: 2009-03
Part Number: Ensemble-capot
Document SubType Name: Assembly
Designer: Ordi1
Author: Ordi1
