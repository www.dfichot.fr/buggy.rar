# Autodesk Inventor assembly: articulation
## iProperties
Created: 2009-03
Part Number: articulation
Document SubType Name: Assembly
Designer: Ordi1
Author: Ordi1
